# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PY32C882xC Puya
  pack: Puya.PY32C88xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32C882xC
  c misc: --no-multibyte-chars
  c include: ..\Inc;..\Drivers\BSP\PY32C882xx_Start_Kit;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32C882\Include;..\Drivers\PY32C882_HAL_Driver\Inc;..\FreeRTOS\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Common
    ./: startup_py32c882xx.s
    ../Src/: system_py32c882.c
  group Application/User
    ../Src/: main.c py32c882_hal_msp.c py32c882_it.c
  group BSP/py32c882xx_Start_Kit
    ../Drivers/BSP/PY32C882xx_Start_Kit/: py32c882xx_Start_Kit.c
  group Drivers/PY32C882_HAL_Driver
    ../Drivers/PY32C882_HAL_Driver/Src/: py32c882_hal.c py32c882_hal_rcc.c py32c882_hal_rcc_ex.c py32c882_hal_gpio.c py32c882_hal_dma.c py32c882_hal_pwr.c py32c882_hal_pwr_ex.c py32c882_hal_uart.c py32c882_hal_cortex.c
  group FreeRTOS_Core
    ../FreeRTOS/Source/: tasks.c queue.c list.c timers.c
  group FreeRTOS_Port
    ../FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group FreeRTOS_Heap
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Config
    ../Inc/: FreeRTOSConfig.h
    ../Src/: app_rtos_hooks.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
